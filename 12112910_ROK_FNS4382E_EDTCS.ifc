Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: c9a70b36-e9bb-4651-8ec8-886a45e36c0b, NumberOfSaves: 1]
File name: 0001
Time: 2025-01-02T08:17:55+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12112910_ROK_FNS4382E_EDTCS:37438250_ROK_12112910_FNS4382E_EDTCS, (2)
In: Default
Type - Material: z_Miele_Design_Glass Black, z_Miele_Design_OBSW, z_Miele_Design_CLST, z_Miele_Design_Steel_Chrom, z_Miele_Connection_Connection_Modul, <Unnamed>, z_Miele_Design_Glass, z_Miele_Design_BRWS
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 600 mm; Height: 1855 mm; Depth: 675 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 37438250_ROK_12112910_FNS4382E_EDTCS; sets with these values: 2

# IfcDistributionPort, Port_355676_1
Description: Flow; FlowDirection: SOURCEANDSINK
